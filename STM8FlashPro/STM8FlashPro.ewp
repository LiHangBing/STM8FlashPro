# IAR project STM8FlashPro.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: STM8S_StdPeriph_Driver\inc; User; User\TIM2_PWM_Out; $PROJ_DIR$; User\UART; User\Delay; User\SPI; User\I2C; User\GPIO
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: STM8FlashPro.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: main.c stm8s_it.c
  group StdPeriph_Driver
    STM8S_StdPeriph_Driver/src/: stm8s_clk.c stm8s_gpio.c stm8s_i2c.c stm8s_spi.c stm8s_tim2.c stm8s_tim4.c stm8s_uart1.c
  group User
    User/: commands.cpp commands.h defines.h gpio_cmd.cpp gpio_cmd.h i2c_cmd.cpp i2c_cmd.h spi_cmd.cpp spi_cmd.h
  group User/User/Delay
    User/Delay/: Delay.c Delay.h
  group User/User/GPIO
    User/GPIO/: GPIO.c GPIO.h
  group User/User/I2C
    User/I2C/: I2C.c I2C.h
  group User/User/SPI
    User/SPI/: SPI.c SPI.h
  group User/User/UART
    User/UART/: UART.c UART.h
